# Keil uVision project STM32F107.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: .\STM32F10x_StdPeriph_Driver\inc;.\stm32f10x_conf;.\User;.\FAT
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c stm32f10x_it.c DMA.c waveplayer.c LCD.C
    C:/Keil_v5/ARM/Startup/ST/: startup_stm32f10x_cl.s
  group CMSIS
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_dac.c stm32f10x_tim.c stm32f10x_dma.c
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
  group SD_Card
    ./User/: sd.c SPI_SD.c usart.c User_systick.c
  group FAT
    ./FAT/: diskio.c ff.c
